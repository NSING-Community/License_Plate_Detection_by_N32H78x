# Keil uVision project Printf.uvprojx, settings and files
target N32H73x_76x (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H760xIx7 Nationstech
  pack: Nationstech.N32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x20000) IROM(0x15000000,0x1E0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Printf +hex
  AfterMake: fromelf --bin --output=.\N32H73x_76x\bin\Printf.bin .\N32H73x_76x\Objects\Printf.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32H73x_76x,CORE_CM7,USE_STDPERIPH_DRIVER,USING_TCM
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32h7xx_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x15000000 size 0x1e0000
  memory RVCT9: RAM 0x24000000 size 0x20000
  scatter file: .\M7_TCM.sct
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32h73x_76x.s startup_n32h78x_cm7.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32h7xx.c
  group FWLB
    ../firmware/n32h7xx_std_periph_driver/src/: misc.c n32h7xx_rcc.c n32h7xx_gpio.c n32h7xx_usart.c n32h7xx_mmu.c n32h7xx_adc.c n32h7xx_sdram.c n32h7xx_dvp.c n32h7xx_lcdc.c n32h7xx_pwr.c
  group USER
    ../src/: main.c n32h7xx_it.c Message.c bsp_sdram.c camera.c bsp_dvp.c bsp_sccb.c bsp_ov5640.c bsp_lcd.c gpu.c
    ./: yolo_inference.cpp
    E:/1 Nations.N32H7xx_Library.1.2.0/middlewares/gpu/lib/: nsgpu.lib
  group BSP
    ../bsp/src/: delay.c
  group DOC
    ../: readme.txt
target N32H78x (6220000::V6.22::ARMCLANG)
  device: N32H787xIx7:CM7 Nationstech
  pack: Nationstech.N32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x20000) IROM(0x15000000,0x001E0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Printf +hex
  AfterMake: fromelf --bin --output=.\N32H78x\bin\Printf.bin .\N32H78x\Objects\Printf.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32H78x,CORE_CM7,USE_STDPERIPH_DRIVER,USING_TCM
  c include: ..\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32h7xx_std_periph_driver\inc;..\bsp\inc;E:\1 Nations.N32H7xx_Library.1.2.0\middlewares\gpu\lib;E:\1 Nations.N32H7xx_Library.1.2.0\middlewares\gpu\tes\kernel\inc;E:\1 Nations.N32H7xx_Library.1.2.0\middlewares\gpu\tes\kernel\src;E:\1 Nations.N32H7xx_Library.1.2.0\middlewares\gpu\tes\user\inc;E:\1 Nations.N32H7xx_Library.1.2.0\middlewares\gpu\tes\user\src
  memory RVCT4: ROM 0x15000000 size 0x1e0000
  memory RVCT9: RAM 0x24000000 size 0x20000
  scatter file: .\M7_TCM.sct
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS:CORE 6.1.0, CMSIS:NN Lib 7.0.0, Data Exchange:Serialization:flatbuffers 1.26.2, Data Processing:Math:gemmlowp fixed-point 1.26.2, Data Processing:Math:kissfft 1.26.2, Data Processing:Math:ruy 1.26.2, Machine Learning:TensorFlow:Kernel Utils 1.26.2, Machine Learning:TensorFlow:Kernel 1.26.2
